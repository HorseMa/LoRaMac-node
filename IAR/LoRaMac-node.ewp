# IAR project LoRaMac-node.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS; xBOARD_NXP_LPCXPRESSO_824; xUSE_RADIO_DEBUG; REGION_CN470
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\src\apps\LoRaMac\classA\MJLoRaWanModem; ..\src\atcmd; ..\src\boards; ..\src\boards\MJLoRaWanModem; ..\src\boards\mcu\lpc824\brd_xpresso824\inc; ..\src\boards\mcu\lpc824\chip_82x\inc; ..\src\mac; ..\src\mac\region; ..\src\radio; ..\src\radio\sx1276; ..\src\system; ..\src\system\crypto
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LoRaMac-node.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../src/apps/LoRaMac/classA/MJLoRaWanModem/: Commissioning.h main.c
  group Lib/Board
    ../src/boards/mcu/lpc824/brd_xpresso824/src/: board_sysinit.c lpc824board.c
  group Lib/Chip
    ../src/boards/mcu/lpc824/chip_82x/src/: acmp_8xx.c adc_8xx.c chip_8xx.c clock_8xx.c crc_8xx.c dma_8xx.c eeprom.c gpio_8xx.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c iap.c iocon_8xx.c irc_8xx.c pinint_8xx.c pmu_8xx.c ring_buffer.c rtc_ut.c sct_8xx.c sct_pwm_8xx.c spi_8xx.c spim_8xx.c spis_8xx.c stopwatch_8xx.c swm_8xx.c syscon_8xx.c sysinit_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c
    ../src/boards/mcu/lpc824/chip_82x/startup/: iar_startup_lpc82x.s sysinit.c
  group LoRaWan/Board
    ../src/boards/MJLoRaWanModem/: board-config.h board.c delay-board.c eeprom-board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c timer.c uart-board.c
    ../src/boards/mcu/: utilities.c
  group LoRaWan/Crypto
    ../src/system/crypto/: aes.c aes.h cmac.c cmac.h
  group LoRaWan/Mac
    ../src/mac/: LoRaMac.c LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacTest.h
    ../src/mac/region/: Region.c Region.h RegionCN470.h RegionCommon.c RegionCommon.h
    ../src/boards/MJLoRaWanModem/: RegionCN470.c
  group LoRaWan/Radio
    ../src/radio/: radio.h
    ../src/boards/MJLoRaWanModem/: sx1276.c
    ../src/radio/sx1276/: sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
